# Keil uVision project nyx.uvproj, settings and files
target nyx (ARM-ADS)
  device: AT91SAM7SE512 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x17FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: nyx
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x80000
  memory RVCT9: RAM 0x200000 size 0x8000
  group AT91SAM7SELib
    ./: AT91SAM7SELib.c AT91SAM7SELib.h
  group core_headers
    ./: AT91SAM7SE512.h AT91SAM7SE-EK.h
  group boot
    ./: SAM7.s
  group main
    ./DMA/: dma_charbuf.c
